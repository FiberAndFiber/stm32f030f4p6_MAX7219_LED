# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: ..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Startup\CMSIS\Device\ST\STM32F0xx\Include;..\Startup\CMSIS\Device\ST\STM32F0xx\Source\Templates;..\Startup\CMSIS\Device\ST\STM32F0xx\Source\Templates\arm;..\User\inc;..\User\src;..\Startup\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../Startup/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    ../Startup/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../Startup/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ../Startup/CMSIS/Include/: core_cm0.h
  group Libraries
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../User/src/: main.c stm32f0xx_it.c AT24C02.c Delay.c FluidSim.c IIC_Scan.c Key.c LED.c MAX7219.c MPU6050.c OLED.c SOFT_I2C_DRIVER.c SOFT_SPI_DRIVER.c
